# Keil uVision project KEA128.uvprojx, settings and files
target KEA128 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KEA128 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\inc;.\drives\inc;.\startup\CoreSupport;.\startup\DeviceSupport\MDK-ARM;.\startup\DeviceSupport;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group startup
    ./startup/DeviceSupport/: system_SKEAZ1284.c
    ./startup/DeviceSupport/MDK-ARM/: startup_SKEAZ1284.s
  group drives
    ./drives/src/: common.c KEA128_flash.c KEA128_adc.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c
  group user
    ./drives/inc/: KEA128_port_cfg.h
    ./USER/: isr.c main.c KEA128_oled.c menu.c control.c KEA128_mcp41.c ui.c KEA128_fxas2100.c KEA128_fxos8700.c KEA128_myiic.c
